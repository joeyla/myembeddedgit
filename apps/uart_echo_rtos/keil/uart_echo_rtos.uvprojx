# Keil uVision project uart_echo_rtos.uvprojx, settings and files
target uart_echo_rtos_f407 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CLOCK(168000000)
  group Application
    ../src/: main.c
  group Core
    ../../../core/src/: cbuf.c timebase.c log.c
  group Services
    ../../../services/at_engine/src/: at_engine.c
  group Platform
    ../../../platform/mcu/stm32f4/src/: mcu_uart_stm32f4.c
    ../../../platform/boards/stm32f407-custom/: board.c
    ../../../platform/os/freertos/src/: os_port_freertos.c
